# Keil uVision project Stm32F103.uvprojx, settings and files
target Stm32F103 (5060960::V5.06 update 7 (build 960)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x800FFFF)  CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: Stm32F103 +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F103xB,ARM_MATH_CM3
  c include: ../Core/Inc;     ../Drivers/STM32F1xx_HAL_Driver/Inc;     ../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy;     ../Drivers/CMSIS/Device/ST/STM32F1xx/Include;     ../Drivers/CMSIS/Include;     ..\..\..\BLL\Inc;     ..\..\..\BSP\Inc;     ..\..\..\OLED_Lib;     ..\..\..\DSP_Lib\CMSIS\Include
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Application/MDK-ARM
    ./: startup_stm32f103xb.s
  group Application/User/Core
    ../../../BLL/: main_app.c
    ../Core/Src/: main.c gpio.c adc.c dma.c i2c.c tim.c usart.c stm32f1xx_it.c stm32f1xx_hal_msp.c
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_adc.c stm32f1xx_hal_adc_ex.c stm32f1xx_hal.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_dma.c stm32f1xx_hal_cortex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_exti.c stm32f1xx_hal_i2c.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f1xx.c
  group DSP_Lib
    E:/RNA_2021_Game_A/MCU Project/DSP_Lib/CMSIS/DSP_Lib/lib/keil/m3/: arm_cortexM3l_math.lib
  group OLED_Lib
    ../../../OLED_Lib/: oled_basic.c oled_bmp.c oled_buffer.c oled_color.c oled_config.c oled_draw.c oled_driver.c oled_font.c
  group BSP
    ../../../BSP/: bsp_init.c bsp_operation.c bsp_it.c
    ../Core/Src/: bsp_led.c
  group BLL
    ../../../BLL/: log.c bll.c my_math.c oled_interface.c simulation.c windowfunction.c
software components: CMSIS:CORE 4.3.0
